# Keil uVision project Matrix_FZS.uvprojx, settings and files
target Matrix_FZS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Matrix_FZS
  BeforeMake: "c:\Program Files (x86)\GnuWin32\bin\astyle" --options="c:\Program Files (x86)\GnuWin32\file\allman.ini" $P\..\Src\*.c
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --thumb
  c include: ../Inc;             ../Drivers/STM32F4xx_HAL_Driver/Inc;             ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;             ../Drivers/CMSIS/Include;             ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Inc/: config.h stm32f4xx_hal_conf.h stm32f4xx_it.h mxconstants.h framebuffer.h main.h matrix.h
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c config.c framebuffer.c matrix.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
  group Application/RO-Data
    ../Inc/fonts/: 6x8_horizontal_LSB_1.h 6x8_horizontal_MSB_1.h 6x8_vertikal_LSB_1.h 6x8_vertikal_MSB_1.h 8x8_vertikal_LSB_1.h 8x8_vertikal_MSB_1.h
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Compiler:I/O:STDERR 1.1.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0
